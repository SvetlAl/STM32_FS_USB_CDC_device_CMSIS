# Keil uVision project usb_cdc_105_lib.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usb_cdc_105_lib +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3
  c include: .\Core\src;.\Core\inc;.\Llib\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ./Core/src/: main.c stm32f105_clock.c stm32f105_usbdfs_cdc.c
    ./Core/inc/: main.h stm32f105_clock.h stm32f105_usbdfs_cdc.h stm32f105_usbdfs_macros.h usb_cdc_desc.h
  group Llib
    ./Llib/inc/: stm32f105xc.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
